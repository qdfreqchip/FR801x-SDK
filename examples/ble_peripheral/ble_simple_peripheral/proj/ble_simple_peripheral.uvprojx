# Keil uVision project ble_simple_peripheral.uvprojx, settings and files
target ble_simple_peripheral (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_simple_peripheral
  AfterMake: fromelf.exe --text -c -o Output/ble_simple_peripheral.txt Objects/ble_simple_peripheral.axf
  AfterMake: fromelf.exe  --bin -o Output/ble_simple_peripheral.bin  Objects/ble_simple_peripheral.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --feedback=feedback.txt
  c include: ..\..\..\..\stack\ble\gap;..\..\..\..\stack\ble\gatt;..\..\..\..\osal\inc;..\..\..\..\stack\ble\profiles\ble_simple_profile;..\..\..\..\drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fr8010_256k.sct
  link misc: --feedback=feedback.txt syscall.txt --entry=user_main --keep=_jump_table --datacompressor=off
  group application
    ../code/application/: ble_simple_peripheral.h ble_simple_peripheral.c proj_main.c
    ../code/config/: app_cfg.h
  group profiles
    ../../../../stack/ble/gap/: gap_api.h
    ../../../../stack/ble/gatt/: gatt_api.h gatt_sig_uuid.h gatt_sig_uuid.c
    ../../../../stack/ble/profiles/ble_simple_profile/: simple_gatt_profile.h simple_gatt_profile.c
  group stack_library
    ../../../../libs/fr801x/: fr801x_ble_4_2.lib
  group osal
    ../../../../osal/inc/: osi.h
software components: CMSIS:CORE 5.0.0
