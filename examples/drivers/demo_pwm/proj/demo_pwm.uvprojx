# Keil uVision project demo_pwm.uvprojx, settings and files
target demo_pwm (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: demo_pwm
  AfterMake: fromelf.exe --text -c -o Output/demo_gio.txt Objects/demo_pwm.axf
  AfterMake: fromelf.exe  --bin -o Output/demo_pwm.bin  Objects/demo_pwm.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --feedback=feedback.txt
  c include: ..\..\..\..\stack\ble\gap;..\..\..\..\stack\ble\gatt;..\..\..\..\osal\inc;..\..\..\..\stack\ble\profiles\ble_simple_profile;..\..\..\..\drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fr8010_256k.sct
  link misc: --feedback=feedback.txt syscall.txt --entry=user_main --keep=_jump_table --datacompressor=off
  group application
    ../code/config/: app_cfg.h
    ../code/application/: proj_main.c
  group profiles
    ../../../../stack/ble/gap/: gap_api.h
    ../../../../stack/ble/gatt/: gatt_api.h
  group stack_library
    ../../../../libs/fr801x/: fr801x_ble_4_2.lib
  group osal
    ../../../../osal/inc/: osi.h
  group driver
    ../../../../drivers/inc/: driver_iomux.h driver_pwm.h driver_gpio.h
software components: CMSIS:CORE 5.0.0
